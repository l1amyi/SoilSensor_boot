# Keil uVision project SoilSensor.uvprojx, settings and files
target GD32F303xB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DemoPrj +hex
  AfterMake: fromelf.exe --bin -o ..\Bin\boot.Bin .\output\DemoPrj.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER GD32F30X_HD
  c include: ..\CMSIS;..\STDLIB;..\STDLIB\inc;..\ChipPeripherals;..\ChipPeripherals\delay;..\ChipPeripherals\Timer;..\ChipPeripherals\usart;..\Peripherals;..\GeneralFunctions;..\GeneralFunctions\AES;..\GeneralFunctions\CheckSum;..\GeneralFunctions\MALLOC;..\GeneralFunctions\string;..\Applications
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    ../Applications/: main.c Interrupt.c systick.c
  group Docs
    ../Logs/: Readme.txt
  group CMSIS
    ../CMSIS/: system_gd32f30x.c startup_gd32f30x_cl.s
  group STDLIB
    ../STDLIB/src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
